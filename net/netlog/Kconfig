## net/netlog/Kconfig
```kconfig
config NETLOG
    tristate "net_log example  module"
    help
      Enable example net_log module.
```
